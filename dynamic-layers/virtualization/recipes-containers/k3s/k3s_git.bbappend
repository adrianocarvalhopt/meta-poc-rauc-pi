FILESEXTRAPATHS:prepend := "${THISDIR}/k3s:"